ORG 00H
SJMP START
ORG 00BH
SJMP KESME
START:
JB P1.0, START
SJMP MAIN
MAIN:
MOV R5, #7H ;1 SNYE YE YACAK TIMER DONGUSU DEGISENI
MOV R4, #05H ;YAKMA VE SONME DURUMLARI GECIS VE TIMER DURUM ICIN DEGISKENI
MOV TMOD, #01H ; 16BIT SAYICI IÇIN
MOV TH0,#00Fh
MOV TL0,#00Fh
CLR TF0
SETB TR0
SETB ET0 ;TIMER 0 IN KESME AKTIVASYONU 
SETB EA ;KESME BASLAMASI
RUN:
CJNE R4,#05H,STOP
CLR P1.1
CLR P1.2
CLR P1.3
CLR P1.6
CLR P2.0
SETB P2.0    ;c harfi olusur.
SETB P1.1
SETB P1.2
SETB P1.3
SETB P1.6


CLR P1.6
CLR P1.3
CLR P2.1    ;2 rakami olusur.
SETB P2.1
SETB P1.3
SETB P1.6

CLR P1.2
CLR P1.5
CLR P1.7
CLR P2.2
SETB P2.2    ;S harfi olusur
SETB P1.2
SETB P1.5
SETB P1.7

CLR P1.2
CLR P1.3
CLR P2.3
SETB P2.3    ;E harfi olusur
SETB P1.2
SETB P1.3
SJMP RUN
STOP:
CJNE R4,#04H,EXIT
CLR P1.7
CLR P1.1
CLR P1.2
CLR P1.3
//CLR P1.4
CLR P1.5
CLR P1.6
SJMP STOP
KESME:
CLR TF0
MOV TH0,#00Fh
MOV TL0,#00Fh
DJNZ R5,DEVAM
MOV R5,#14H
DEC R4
CJNE R4,#03H,DEVAM
RETI
DEVAM:
SETB TR0
RETI
EXIT:
LJMP START
END